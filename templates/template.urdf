Commit message: feat: load x urdfs

File: templates/template.urdf (robot description, URDF)
Before this commit: robot TEMPLATE.urdf, 1 links, 0 joints
Links:
- link baseLink: mass .1 -> 10
